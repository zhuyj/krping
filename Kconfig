## Kconfig
```kconfig
config KRPERF
	tristate "Kernel RDMA Perf/Ping Module"
	depends on INFINIBAND 
	---help---
	  Development tool module implementing a RDMA perf/ping client/server.
```
